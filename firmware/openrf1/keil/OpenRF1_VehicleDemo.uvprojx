# Keil uVision project OpenRF1_VehicleDemo.uvprojx, settings and files
target OpenRF1_VehicleDemo (6240000::V6.24::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenRF1_VehicleDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\vehicle_demo
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../vehicle_demo/: main_vehicle_demo.c obstacle_control.c platform_vehicle_demo.c ultrasonic_array.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
