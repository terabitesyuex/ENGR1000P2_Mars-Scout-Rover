# Keil uVision project OpenRF1_Motor_Bringup.uvprojx, settings and files
target OpenRF1_Motor_Bringup (6240000::V6.24::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenRF1_Motor_Bringup +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\motor_bringup;..\vehicle_demo
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../motor_bringup/: main_motor_bringup.c motor_control.c platform_motor_bringup.c
    ../vehicle_demo/: encoder_input.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
