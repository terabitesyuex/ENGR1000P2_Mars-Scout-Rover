# Keil uVision project OpenRF1_RoverControl_Foundation.uvprojx, settings and files
target OpenRF1_RoverControl_Foundation (6240000::V6.24::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenRF1_RoverControl_Foundation +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\app;..\app\control;..\app\drivers\motor;..\app\drivers\encoder;..\app\config
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../app/rover_control/: main_rover_control_foundation.c
    ../app/drivers/motor/: motor.c
    ../app/drivers/encoder/: encoder.c
    ../app/control/: mecanum.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
