# Keil uVision project OpenRF1_HCSR04_Bringup.uvprojx, settings and files
target OpenRF1_HCSR04_Bringup (6240000::V6.24::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpenRF1_HCSR04_Bringup +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\hcsr04_bringup;..\full_hardware;..\app
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../hcsr04_bringup/: hcsr04.c main_hcsr04_bringup.c platform_hcsr04_bringup.c telemetry_hcsr04_bringup.c
    ../full_hardware/: openrf1_status.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
